Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X_PLATFORM
File name: Default Project
Time: 2010-08-27T16:18:14
Written by: Revit Architecture 2009 - 1.0
Made in: 20080321_1900

# IfcSite, Default
RefLatitude: 42, 12, 46, 800000; RefLongitude: -71, -1, -58, -800000; RefElevation: 0 mm

# IfcBuildingStorey, Level 1
Elevation: 0 mm
PSet_Revit_Identity Data - Name: Level 1
PSet_Revit_Constraints - Elevation: 0 mm
PSet_Revit_Type_Graphics - Line Weight: 1; Color: 0; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
PSet_Revit_Type_Constraints - Elevation Base: 0
PSet_Revit_Type_Dimensions - Automatic Room Computation Height: no; Computation Height: 1200 mm

# IfcBuildingElementProxy: FM Mattsson 9651-0010, 96510010_ifc:FM Mattsson 9651-0010:FM Mattsson 9651-0010:109807
In: Level 1
PSet_Revit_Dimensions - Washbasin Height: 850 mm
PSet_Revit_Constraints - Host: Level : Level 1; Offset: 0 mm; Moves With Nearby Elements: no
PSet_Revit_Identity Data - Mark: 6
PSet_Revit_Type_Identity Data - VVS: -; URL: www.fmmattsson.com; RSK: 8235394; NRF: -; Model: 9651-0010; Manufacturer: FM Mattsson AB; LVI: -; Family: FM GARDA; EAN: 7391887229435; Description: Single Lever Basin Mixer w. extended base, Chrome
